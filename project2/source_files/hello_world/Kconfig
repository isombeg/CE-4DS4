## project2/source_files/hello_world/Kconfig
```kconfig
menuconfig EXAMPLES_HELLO_WORLD
 bool "hello_world"
 default n
 ---help---
 Enable support for hello_world
```
